# Keil uVision project project.uvproj, settings and files
target Curtain (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./: main.c
  group Module
    ./: Delay.c Delay.h Motor.c Motor.h LCD1602.c LCD1602.h ADC0832.c ADC0832.h Key.c Key.h LightControl.h LightControl.c Bluetooth.c Bluetooth.h UART.c UART.h
